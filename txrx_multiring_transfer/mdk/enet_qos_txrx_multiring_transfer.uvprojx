# Keil uVision project enet_qos_txrx_multiring_transfer.uvprojx, settings and files
target enet_qos_txrx_multiring_transfer debug (ARM-ADS)
  device: MCXE31BMPB NXP
  pack: NXP.MCXE31B_DFP.25.06.00
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: enet_qos_txrx_multiring_transfer.out
  AfterMake: fromelf.exe --output "$Lenet_qos_txrx_multiring_transfer.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 wLevel=3
  c define: DEBUG, FSL_ETH_ENABLE_CACHE_CONTROL, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MCXE31BMPB, MCXE31B_SERIES, BOOT_HEADER_ENABLE=1
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../boot_header;../../../../../../devices/MCXE31B/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MCXE31B;../../../../../../devices/MCXE31B/periph1;../../../../../../devices/MCXE31B/utilities/debug_console_lite;../../../../../../devices/MCXE31B/utilities/str;../../../../../../components/uart;../../../../../../components/phy;../../../../../../components/phy/device/phylan8741
  asm define: MCUXPRESSO_SDK, CPU_MCXE31BMPB, MCXE31B_SERIES
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x21400000 size 0x10000
  memory RVCT7: RAM 0x0 size 0x8000
  memory RVCT8: RAM 0x11400000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MCXE31B_flash.scf
  link misc: --remove --predefine="-D__stack_size__=0x1000" --predefine="-D__heap_size__=0x8000" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: enet_qos_txrx_multiring_transfer.c ZephyrMap_Gen.h mcux_config.h mcux_config.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.h pin_mux.c hardware_init.c app.h
  group boot_header
    ../../../../boot_header/: boot_header.c boot_header.h
  group drivers
    ../../../../../../devices/MCXE31B/drivers/: fsl_clock.c fsl_clock.h fsl_memory.h fsl_siul2.c fsl_siul2.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_enet_qos.h fsl_enet_qos.c fsl_lpuart.h fsl_lpuart.c
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../../devices/MCXE31B/: fsl_device_registers.h MCXE31B.h MCXE31B_features.h MCXE31B_COMMON.h system_MCXE31B.c system_MCXE31B.h
  group device/periph1
    ../../../../../../devices/MCXE31B/periph1/: PERI_ADC.h PERI_AXBS_LITE.h PERI_BCTU.h PERI_CAN.h PERI_CMU_FC.h PERI_CMU_FM.h PERI_CONFIGURATION.h PERI_CRC.h PERI_DCM.h PERI_DCM_GPR.h PERI_DMA.h PERI_DMAMUX.h PERI_EIM.h PERI_EMAC.h PERI_EMIOS.h PERI_ERM.h PERI_FCCU.h PERI_FIRC.h PERI_FLASH.h PERI_FLEXIO.h PERI_FXOSC.h PERI_I2S.h PERI_INTM.h PERI_JDC.h PERI_LCU.h PERI_LPCMP.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPUART.h PERI_MCM.h PERI_MC_CGM.h PERI_MC_ME.h PERI_MC_RGM.h PERI_MDM_AP.h PERI_MSCM.h PERI_MU.h PERI_PFLASH.h PERI_PIT.h PERI_PLL.h PERI_PMC.h PERI_PRAMC.h PERI_QUADSPI.h PERI_QUADSPI_ARDB.h PERI_RTC.h PERI_SDA_AP.h PERI_SELFTEST.h PERI_SEMA42.h PERI_SIRC.h PERI_SIUL2.h PERI_STCU.h PERI_STM.h PERI_SWT.h PERI_SXOSC.h PERI_TEMPSENSE.h PERI_TRGMUX.h PERI_TSPC.h PERI_VIRT_WRAPPER.h PERI_WKPU.h PERI_XBIC.h PERI_XRDC.h
  group startup
    ../../../../../../devices/MCXE31B/: startup_MCXE31B.c
  group utilities
    ../../../../../../devices/MCXE31B/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MCXE31B/utilities/: fsl_memcpy.S
  group utilities/str
    ../../../../../../devices/MCXE31B/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MCXE31B/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/phy
    ../../../../../../components/phy/: fsl_phy.h
  group phy
    ../../../../../../components/phy/device/phylan8741/: fsl_phylan8741.c fsl_phylan8741.h
  group doc
    ../: readme.md example_board_readme.md
target enet_qos_txrx_multiring_transfer release (ARM-ADS)
  device: MCXE31BMPB NXP
  pack: NXP.MCXE31B_DFP.25.06.00
  cpu: CPUTYPE("Cortex-M7") FPU3(SFPU)
  output: enet_qos_txrx_multiring_transfer.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 wLevel=3
  c define: NDEBUG, FSL_ETH_ENABLE_CACHE_CONTROL, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MCXE31BMPB, MCXE31B_SERIES, BOOT_HEADER_ENABLE=1
  c misc: as above
  c include: as above
  asm define: MCUXPRESSO_SDK, CPU_MCXE31BMPB, MCXE31B_SERIES
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT6: RAM 0x21400000 size 0x10000
  memory RVCT7: RAM 0x0 size 0x8000
  memory RVCT8: RAM 0x11400000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: MCXE31B_flash.scf
  link misc: as above

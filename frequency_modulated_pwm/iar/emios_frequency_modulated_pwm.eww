<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>emios_frequency_modulated_pwm</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>emios_frequency_modulated_pwm</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>emios_frequency_modulated_pwm</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>emios_frequency_modulated_pwm</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/emios_frequency_modulated_pwm.ewp</path>
  </project>
</workspace>

<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>virt_wrapper_siul2_example</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>virt_wrapper_siul2_example</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>virt_wrapper_siul2_example</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>virt_wrapper_siul2_example</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/virt_wrapper_siul2_example.ewp</path>
  </project>
</workspace>
